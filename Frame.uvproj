# Keil uVision project Frame.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Frame +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s delay.c main.c usart.c sys.c init.c
